#include "render.h"
#include <cstdio>
#include <trmnl_log.h>

#ifdef BOARD_TRMNL_X

#include "FastEPD.h"
extern FASTEPD bbep;

// Font headers (Group5 compressed, generated by fontconvert)
#include "fonts/dseg7_clock.h"
#include "fonts/dseg7_data.h"
#include "fonts/dseg14_text.h"
#include "fonts/ubuntu_labels.h"

// Map FontId enum to font data pointers
static const uint8_t* fontTable[LAYOUT_FONT_COUNT] = {};

void render_init(void) {
    fontTable[FONT_DSEG7_CLOCK]  = dseg7_clock;
    fontTable[FONT_DSEG7_DATA]   = dseg7_data;
    fontTable[FONT_DSEG14_TEXT]  = dseg14_text;
    fontTable[FONT_UBUNTU_LABEL] = ubuntu_labels;
    Log_info("Render: fonts loaded (%d faces)", LAYOUT_FONT_COUNT);
}

void renderDrawList(const DrawList& dl) {
    Log_info("Render: drawing %d commands", dl.count);

    for (int i = 0; i < dl.count; i++) {
        const DrawCmd& cmd = dl.cmds[i];

        switch (cmd.type) {
        case DRAW_TEXT: {
            const uint8_t* font = fontTable[cmd.text.font];
            if (!font) {
                Log_error("Render: null font for id=%d", cmd.text.font);
                break;
            }
            bbep.setFont(font);
            // Transparent background so overlapping draws layer instead of
            // painting white boxes over each other.
            bbep.setTextColor(cmd.ink, BBEP_TRANSPARENT);
            bbep.setCursor(cmd.x, cmd.y);
            // The DSEG faces are segment displays generated with no lowercase
            // glyphs (dseg14_text covers ' '..'Z'), and bb_epaper stops drawing
            // at the first char outside the range — so "Kumlinge" rendered as
            // "K". The prototype sets text-transform: uppercase for these, so
            // fold here rather than paying for ~30 more glyphs per face.
            //
            // 'S' is also folded to '5'. On a segment display the two are the
            // same shape, and DSEG's 'S' is the uglier drawing of it — the '5'
            // reads more cleanly at these sizes. Affects SUN/SAT and any
            // station name containing an S.
            if (cmd.text.font == FONT_DSEG14_TEXT ||
                cmd.text.font == FONT_DSEG7_CLOCK ||
                cmd.text.font == FONT_DSEG7_DATA) {
                char up[64];
                size_t n = 0;
                for (const char* p = cmd.text.text; *p && n < sizeof(up) - 1; p++, n++) {
                    char ch = (*p >= 'a' && *p <= 'z') ? (char)(*p - 'a' + 'A') : *p;
                    up[n] = (ch == 'S') ? '5' : ch;
                }
                up[n] = '\0';
                bbep.print(up);
            } else {
                bbep.print(cmd.text.text);
            }
            break;
        }
        case DRAW_LINE:
            // drawLine has no thickness, so draw parallel copies offset
            // PERPENDICULAR to the line. Offsetting purely in x or y (chosen by
            // whether the line is horizontal) only works for axis-aligned
            // lines: a 45-degree wind arrow offset that way slides along its own
            // direction and barely thickens at all.
            {
                int lx = cmd.line.x2 - cmd.x;
                int ly = cmd.line.y2 - cmd.y;
                int alx = lx < 0 ? -lx : lx;
                int aly = ly < 0 ? -ly : ly;
                // Unit normal, quantised to the dominant axis for the shallow
                // cases and to the diagonal otherwise — enough for a few px.
                int nx, ny;
                if (aly * 2 < alx)      { nx = 0;                ny = 1; }
                else if (alx * 2 < aly) { nx = 1;                ny = 0; }
                else                    { nx = (ly > 0) ? 1 : -1; ny = (lx > 0) ? -1 : 1; }
                for (int t = 0; t < cmd.line.thickness; t++) {
                    int off = t - cmd.line.thickness / 2;
                    bbep.drawLine(cmd.x + nx * off, cmd.y + ny * off,
                                  cmd.line.x2 + nx * off, cmd.line.y2 + ny * off,
                                  cmd.ink);
                }
            }
            break;

        case DRAW_RECT_FILL:
            bbep.fillRect(cmd.x, cmd.y, cmd.rect.w, cmd.rect.h, cmd.ink);
            break;
        }
    }
}

void renderPartial(const DrawList& dl) {
    bbep.setMode(BB_MODE_2BPP);
    bbep.fillScreen(INK_WHITE);
    renderDrawList(dl);
    bbep.partialUpdate(false);
    Log_info("Render: partial refresh done");
}

void renderFull(const DrawList& dl) {
    bbep.setMode(BB_MODE_2BPP);
    bbep.fillScreen(INK_WHITE);
    renderDrawList(dl);
    bbep.fullUpdate();
    // fullUpdate() leaves pPrevious matching what is on the panel, so the next
    // renderClockUpdate() can partial-update against it.
    bbep.setPreviousMode(BB_MODE_2BPP);
    Log_info("Render: full refresh done");
}

void renderClockUpdate(int hour, int minute) {
    // Render new time into pCurrent and partial-update the clock rows.
    // pPrevious already reflects what is on screen — either from the renderFull()
    // that drew this screen, or from the previous tick. Light sleep preserves
    // PSRAM, so nothing needs reconstructing after a wake (see clock91.cpp).
    //
    // LAYOUT_CLOCK_Y is a baseline and the digits are drawn upward from it, so
    // the refresh window starts an ascent above it — not at it. CLOCK_ASCENT
    // matches the generated dseg7_clock (see layout.h); the margin absorbs the
    // few px of descent the ':' glyph can sit below the baseline.
    const int CLOCK_ASCENT = LAYOUT_CLOCK_ASCENT;
    int y_start = LAYOUT_CLOCK_Y - CLOCK_ASCENT;
    int y_end = LAYOUT_CLOCK_Y + 20;
    char buf[8];

    // Mode is set explicitly rather than inherited: display.cpp drives the panel
    // in 1/2/4bpp for setup and error screens, so whatever ran last is not
    // guaranteed to have left us in 2bpp.
    bbep.setMode(BB_MODE_2BPP);

    // Clear ONLY the clock rectangle — these rows, and only the columns left of
    // the vertical split.
    //
    // fillScreen() would blank the whole framebuffer, and clearing the full row
    // width blanks the right-hand half of these rows: the NOW wind/gust/air
    // values sit at y=122 and the history graph spans y~162-302, all inside the
    // clock's row band. Either way partialUpdate() then pushes just these rows,
    // so that content disappears from the panel on the first minute tick while
    // pCurrent claims it is white.
    bbep.fillRect(0, y_start, LAYOUT_CLOCK_CLEAR_W, y_end - y_start, INK_WHITE);
    bbep.setFont(fontTable[FONT_DSEG7_CLOCK]);

    // No 88:88 ghost. 2bpp has four levels — black, dark gray, light gray,
    // white — so light gray is already the lightest ink that marks the panel,
    // and on the real display it is heavy enough to compete with the live
    // digits rather than sit behind them. sRGB previews flatter it badly.
    // buildLayout() never drew a ghost either, so the full refresh and the
    // minute tick now agree.
    bbep.setTextColor(INK_BLACK, INK_WHITE);
    snprintf(buf, sizeof(buf), "%02d:%02d", hour, minute);
    bbep.setCursor(LAYOUT_CLOCK_X, LAYOUT_CLOCK_Y);
    bbep.print(buf);

    bbep.partialUpdate(false, y_start, y_end);
    Log_info("Render: clock update %s (rows %d-%d)", buf, y_start, y_end);
}

// ── RLE bitmap blitter ──
// Decodes RLE-compressed 2BPP data and blits onto the framebuffer.
// Ink levels 0=black 1=dark 2=light 3=white; white is transparent, so the cup
// composites over whatever is already on screen rather than punching a hole.

#include "coffee_cup.h"

// Emit one packed byte — four 2-bit pixels, MSB-first pairs.
static inline void blitByte2BPP(uint8_t val, int col_byte, int row,
                                int dst_x, int dst_y, int img_w) {
    if (val == 0xFF) return;   // all four pixels white: nothing to draw
    for (int slot = 0; slot < 4; slot++) {
        int px = col_byte * 4 + slot;
        if (px >= img_w) break;
        uint8_t ink = (val >> (6 - slot * 2)) & 0x3;
        if (ink == INK_WHITE) continue;
        bbep.drawPixelFast(dst_x + px, dst_y + row, ink);
    }
}

static void blitRLE2BPP(const uint8_t* rle, int rle_len,
                        int dst_x, int dst_y, int img_w, int img_h, int stride) {
    const int total_bytes = stride * img_h;
    int src_pos = 0;   // decoded byte index
    int rle_idx = 0;   // position in the RLE stream
    int row = 0, col_byte = 0;

    while (rle_idx < rle_len && src_pos < total_bytes) {
        uint8_t cmd = rle[rle_idx++];
        // 0x00-0x7F: repeat the next byte (cmd+1) times.
        // 0x80-0xFF: (cmd-128+1) literal bytes follow.
        const bool is_run = (cmd <= 0x7F);
        int count = is_run ? (cmd + 1) : (cmd - 128 + 1);
        uint8_t run_val = 0;
        if (is_run) {
            if (rle_idx >= rle_len) break;
            run_val = rle[rle_idx++];
        }

        for (int i = 0; i < count && src_pos < total_bytes; i++) {
            uint8_t val;
            if (is_run) {
                val = run_val;
            } else {
                if (rle_idx >= rle_len) return;
                val = rle[rle_idx++];
            }
            blitByte2BPP(val, col_byte, row, dst_x, dst_y, img_w);
            src_pos++;
            if (++col_byte >= stride) { col_byte = 0; row++; }
        }
    }
}

static const uint8_t* steam_frames[] = {COFFEE_STEAM_0, COFFEE_STEAM_1, COFFEE_STEAM_2};
static const int steam_lens[] = {COFFEE_STEAM_0_LEN, COFFEE_STEAM_1_LEN, COFFEE_STEAM_2_LEN};

void renderCoffeeCup(int base_x, int base_y, int frame) {
    // Steam: upper portion, centred horizontally in the column
    int steam_x = base_x + (LAYOUT_CUP_ZONE_W - COFFEE_STEAM_0_W) / 2;
    int steam_y = base_y;
    int f = frame % 3;
    blitRLE2BPP(steam_frames[f], steam_lens[f],
                steam_x, steam_y, COFFEE_STEAM_0_W, COFFEE_STEAM_0_H, COFFEE_STEAM_0_STRIDE);

    // Mug: below steam, centred
    int mug_x = base_x + (LAYOUT_CUP_ZONE_W - COFFEE_MUG_W) / 2;
    int mug_y = base_y + COFFEE_STEAM_0_H - 40;  // overlap slightly
    blitRLE2BPP(COFFEE_MUG, COFFEE_MUG_LEN,
                mug_x, mug_y, COFFEE_MUG_W, COFFEE_MUG_H, COFFEE_MUG_STRIDE);
}

static void renderTimerCommon(const DrawList& dl, int cup_frame) {
    bbep.setMode(BB_MODE_2BPP);
    bbep.fillScreen(INK_WHITE);
    renderDrawList(dl);
    renderCoffeeCup(LAYOUT_CUP_X, LAYOUT_CUP_Y, cup_frame);
}

void renderTimerFrame(const DrawList& dl, int cup_frame) {
    renderTimerCommon(dl, cup_frame);
    bbep.partialUpdate(false);
    Log_info("Render: timer frame (%d cmds, steam %d)", dl.count, cup_frame);
}

void renderTimerFull(const DrawList& dl, int cup_frame) {
    renderTimerCommon(dl, cup_frame);
    bbep.fullUpdate();
    Log_info("Render: timer full (%d cmds, steam %d)", dl.count, cup_frame);
}

#else
// Stub for non-TRMNL_X builds — these functions are never called
void render_init(void) {}
void renderDrawList(const DrawList&) {}
void renderPartial(const DrawList&) {}
void renderFull(const DrawList&) {}
void renderClockUpdate(int, int) {}
void renderTimerFull(const DrawList&, int) {}
void renderTimerFrame(const DrawList&, int) {}
#endif // BOARD_TRMNL_X
